require librealsense.inc

SRC_URI = "git://github.com/IntelRealSense/librealsense.git"
SRCREV = "c35b9f79d175ad10b4e6b0b511c0d2e1642578b4"

PR = "r0"

S = "${WORKDIR}/git"
